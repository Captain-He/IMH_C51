# Keil uVision project xiu.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: xiu +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DS3231_Clock.c DS3231.h Led.h LedSegmentDisplay.h Protect.h HCSR04.h
